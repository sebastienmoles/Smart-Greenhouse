# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STCubeGenerated
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303x8
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F3xx_HAL_Driver/Inc;   ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;   ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f303x8.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_cortex.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_dma.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_adc.c
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c main.c stm32f3xx_it.c uart.c i2c.c adc.c pwm.c
    ../Inc/: uart.h i2c.h adc.h pwm.h
software components: CMSIS:CORE 4.1.0
